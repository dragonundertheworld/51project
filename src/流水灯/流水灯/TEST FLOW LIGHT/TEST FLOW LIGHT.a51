ORG 0000H
	LJMP MAIN
ORG 000BH
LJMP RELOAD
ORG 1000H
MAIN:
MOV TMOD,#01H;TMOD:GATE(T1是否受INT1,INT0影响),C/T,M1,M0,GATE(T0是否受INT1,INT0影响),C/T,M1,M0
MOV TH0,#3CH
MOV TL0,#0B0H;T1(P3.5)=TH1+TL1;50ms=0.05s
MOV R1,#20
SETB EA;总允许
SETB ET0;T0原允许
MOV P2, #11110101B;主程序
LCALL LOOP
MOV P2, #11111010B;主程序
LCALL LOOP
LJMP MAIN
LOOP:
SETB TR0
DJNZ R1,LOOP
RETI
RELOAD:
MOV TH0,#3CH
MOV TL0,#0B0H;T1(P3.5)=TH1+TL1;50ms=0.05s
CLR TF0
RETI


END