# Keil uVision project 步进电机.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 步进电机 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: MOTOR.a51
